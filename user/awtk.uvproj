# Keil uVision project awtk.uvproj, settings and files
target awtk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: awtk_demo1 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,NDEBUG,HAS_AWTK_CONFIG
  c include: ..\stm32f10x_fwlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user;..\core;..\app\led;..\app\beep;..\app\button;..\app\exti;..\app\iwdg;..\app\wwdg;..\app\tim;..\app\tpad;..\app\lcd;..\app\gui;..\USMART;..\app\rtc;..\app\wkup;..\app\adc;..\app\tsensor;..\app\dac;..\app\dma;..\app\AT24Cxx;..\app\IIC(24C02);..\app\spi;..\app\W25QXX;..\app\rs485;..\app\can;..\app\DS18B20;..\app\DHT11;..\app\adxl345;..\app\nrf24l01;..\app\stm32_flash;..\app\sram;..\app\malloc;..\app\SysTick;..\app\RTC_J;..\app\touch;..\awtk\src;..\awtk\3rd;..\awtk\;..\awtk-port\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group system
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../stm32f10x_fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group app
    ../app/led/: led.c
    ../app/lcd/: lcd_driver.c
    ../app/button/: button.c
    ../app/tim/: tim.c
    ../app/rtc/: rtc.c
    ../app/touch/: touch.c spi.c flash.c
    ../app/gui/: gui.c
  group awtk-port
    ../awtk-port/: lcd_stm32_raw.c main_loop_stm32_raw.c platform.c
    ../awtk-lite/src/platforms/raw/: mutex_null.c sys_tick.c fs_os.c
  group awtk-demo
    ../awtk-lite/demos/: demo_main.c demo1_app.c assets-mini.c
  group awtk
    ../awtk-lite/src/base/: assets_manager.c bitmap.c canvas.c dialog.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c idle.c idle_info.c idle_manager.c image_base.c image_loader.c image_manager.c input_device_status.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c style.c style_const.c style_factory.c style_mutable.c system_info.c theme.c timer.c timer_info.c timer_manager.c vgcanvas.c widget.c widget_factory.c widget_vtable.c window.c window_base.c window_manager.c
    ../awtk-lite/src/font_loader/: font_loader_bitmap.c
    ../awtk-lite/src/main_loop/: main_loop_simple.c
    ../awtk-lite/src/native_window/: native_window_raw.c
    ../awtk-lite/src/tkc/: buffer.c color.c color_parser.c darray.c date_time.c easing.c emitter.c event.c fs.c mem.c named_value.c object.c object_default.c path.c rect.c slist.c str.c time_now.c utf8.c utils.c value.c wstr.c
    ../awtk-lite/src/widgets/: button.c button_group.c check_button.c color_tile.c dialog_client.c dialog_helper.c dialog_title.c group_box.c image.c label.c pages.c popup.c progress_bar.c slider.c tab_button.c widgets.c
    ../awtk-lite/src/window_manager/: window_manager_simple.c
    ../awtk-lite/src/: awtk_global.c
    ../awtk-lite/lite/src/: dummy.c
